## drivers/rekernel/Kconfig
```kconfig
config REKERNEL
	tristate "Re:Kernel"
	default y
	help
	  Support Re:Kernel for better Tombstone functionality.
```
